# Keil uVision project minimalpro.uvproj, settings and files
target minimalpro (ARM-ADS)
  device: STM32F050K6 STMicroelectronics
  cpu: IRAM(0x20000000-0x20000FFF) IROM(0x8000000-0x8007FFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: minimalpro +hex
  c flags: Optim=1 OneElfS=1
  c define: USE_STDPERIPH_DRIVER
  c include: .\stm32\stm32f0;.\stm32\lib\inc;.\uart;.\minimal;.\minimal\minimal
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group helpers
    ./minimal/: checksum.c mavlink_helpers.c protocol.c
  group msg
    ./minimal/minimal/: testsuite.c mavlink_msg_heartbeat.c mavlink_msg_statustext.c mavlink_msg_ahrs.c mavlink_msg_attitude.c mavlink_msg_global_position_int.c mavlink_msg_gps_raw_int.c mavlink_msg_gps_status.c mavlink_msg_hwstatus.c mavlink_msg_limits_status.c mavlink_msg_meminfo.c mavlink_msg_mission_current.c mavlink_msg_mission_request.c mavlink_msg_nav_controller_output.c mavlink_msg_param_value.c mavlink_msg_raw_imu.c mavlink_msg_rc_channels_raw.c mavlink_msg_rc_channels_scaled.c mavlink_msg_scaled_pressure.c mavlink_msg_sensor_offsets.c mavlink_msg_servo_output_raw.c mavlink_msg_simstate.c mavlink_msg_sys_status.c mavlink_msg_vfr_hud.c
  group loop
    ./: OpenTel_Mavlink.c main.c
  group UART
    ./uart/: uart.c fifo.c
  group stm32f0
    ./stm32/stm32f0/: stm32f0xx_it.c system_stm32f0xx.c startup_stm32f0xx.s
  group lib
    ./stm32/lib/src/: stm32f0xx_adc.c stm32f0xx_cec.c stm32f0xx_comp.c stm32f0xx_crc.c stm32f0xx_dac.c stm32f0xx_dbgmcu.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_rtc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_wwdg.c
